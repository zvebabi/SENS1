# Keil uVision project sens_one.uvproj, settings and files
target sens_one_test (MCS-51)
  device: C8051F061 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: sens_one +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: HELLO.C
